options:
  parameters:
    generate_options: qt_gui
    id: CosineSource
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '1380000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: g:/SoapyIC7610IQ_new/obsolete/datacapcf32.dat
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: G:\SoapyIC7610IQ_new\bin\cf32_1_26_test_data_1,data
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '32767'
    ymin: '-32768'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Waterfall"'
    type: complex
    wintype: window.WIN_HANN
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
